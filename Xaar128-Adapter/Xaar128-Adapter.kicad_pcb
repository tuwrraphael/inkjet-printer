File: Xaar128-Adapter/Xaar128-Adapter.kicad_pcb (KiCad board)
At the start: 2 copper layers, 41 x 38 mm, 15 parts, among them J1 Conn_01x21, J2 Conn_02x15_Odd_Even, J3 Conn_01x12, Q1 DMN2075U

Commit message: adapter mostly done
Parts:
- D1, D2: footprint LED_THT:LED_D3.0mm -> Custom_LED_THT:LED_D3.0mm
- moved NT1 1.27 mm to (131.8, 100.8)
- moved NT2 1.02 mm to (131.8, 94.5)
Routing:
- net GNDH: track 31.9 -> 33.7 mm
- net VPPH: track 36.9 -> 38.5 mm
- net Net-(NT1-Pad1): track 4.11 -> 2.78 mm
- net Net-(D2-K): track 5.52 -> 4.77 mm
Other:
- board text added: "Todo: Connector Silkscreen Connector Hole Clearance"
Changed lines of the file:
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@@
   (net 33 "Net-(Q1-G)")
   (net 34 "Net-(NT1-Pad1)")
-  (footprint "LED_THT:LED_D3.0mm" (layer "F.Cu")
+  (footprint "Custom_LED_THT:LED_D3.0mm" (layer "F.Cu")
     (at 155.702 98)
     (descr "LED, diameter 3.0mm, 2 pins")
@@
         (effects (font (size 1 1) (thickness 0.15)))
     )
-    (fp_line (start -0.29 -1.236) (end -0.29 -1.08)
+    (fp_arc (start -0.179325 -1.373045) (mid 1.387145 -1.993006) (end 2.8702 -1.1938)
       (stroke (width 0.12) (type solid)) (layer "F.SilkS"))
-    (fp_line (start -0.29 1.08) (end -0.29 1.236)
+    (fp_arc (start 0.381 -1.193799) (mid 1.27 -1.488448) (end 2.159 -1.193799)
       (stroke (width 0.12) (type solid)) (layer "F.SilkS"))
-    (fp_arc (start -0.29 -1.235516) (mid 1.366487 -1.987659) (end 2.942335 -1.078608)
+    (fp_arc (start 2.1082 1.2446) (mid 1.269999 1.500536) (end 0.431798 1.244599)
       (stroke (width 0.12) (type solid)) (layer "F.SilkS"))
-    (fp_arc (start 0.229039 -1.08) (mid 1.270117 -1.5) (end 2.31113 -1.079837)
-      (stroke (width 0.12) (type solid)) (layer "F.SilkS"))
-    (fp_arc (start 2.31113 1.079837) (mid 1.270117 1.5) (end 0.229039 1.08)
-      (stroke (width 0.12) (type solid)) (layer "F.SilkS"))
-    (fp_arc (start 2.942335 1.078608) (mid 1.366487 1.987659) (end -0.29 1.235516)
+    (fp_arc (start 2.8194 1.27) (mid 1.387087 1.999958) (end -0.12062 1.442122)
       (stroke (width 0.12) (type solid)) (layer "F.SilkS"))
     (fp_line (start -1.15 -2.25) (end -1.15 2.25)
@@
     )
   )
-  (footprint "LED_THT:LED_D3.0mm" (layer "F.Cu")
+  (footprint "Custom_LED_THT:LED_D3.0mm" (layer "F.Cu")
     (at 128.275 98 180)
     (descr "LED, diameter 3.0mm, 2 pins")
@@
     (property "ki_keywords" "LED diode")
     (attr through_hole)
-    (fp_text reference "D2" (at 1.27 -2.96) (layer "F.SilkS")
+    (fp_text reference "D2" (at 1.27 -2.96 180) (layer "F.SilkS")
         (effects (font (size 1 1) (thickness 0.15)))
     )
-    (fp_text value "LED green Vf=1.8V" (at 1.27 2.96) (layer "F.Fab")
+    (fp_text value "LED green Vf=1.8V" (at 1.27 2.96 180) (layer "F.Fab")
         (effects (font (size 1 1) (thickness 0.15)))
     )
-    (fp_line (start -0.29 -1.236) (end -0.29 -1.08)
+    (fp_arc (start -0.179325 -1.373045) (mid 1.387145 -1.993006) (end 2.8702 -1.1938)
       (stroke (width 0.12) (type solid)) (layer "F.SilkS"))
-    (fp_line (start -0.29 1.08) (end -0.29 1.236)
+    (fp_arc (start 0.381 -1.193799) (mid 1.27 -1.488448) (end 2.159 -1.193799)
       (stroke (width 0.12) (type solid)) (layer "F.SilkS"))
-    (fp_arc (start -0.29 -1.235516) (mid 1.366487 -1.987659) (end 2.942335 -1.078608)
+    (fp_arc (start 2.1082 1.2446) (mid 1.269999 1.500536) (end 0.431798 1.244599)
       (stroke (width 0.12) (type solid)) (layer "F.SilkS"))
-    (fp_arc (start 0.229039 -1.08) (mid 1.270117 -1.5) (end 2.31113 -1.079837)
-      (stroke (width 0.12) (type solid)) (layer "F.SilkS"))
-    (fp_arc (start 2.31113 1.079837) (mid 1.270117 1.5) (end 0.229039 1.08)
-      (stroke (width 0.12) (type solid)) (layer "F.SilkS"))
-    (fp_arc (start 2.942335 1.078608) (mid 1.366487 1.987659) (end -0.29 1.235516)
+    (fp_arc (start 2.8194 1.27) (mid 1.387087 1.999958) (end -0.12062 1.442122)
       (stroke (width 0.12) (type solid)) (layer "F.SilkS"))
     (fp_line (start -1.15 -2.25) (end -1.15 2.25)
@@
   )
   (footprint "NetTie:NetTie-2_SMD_Pad0.5mm" (layer "B.Cu")
-    (at 132.842 94.488 180)
+    (at 131.818 94.488 180)
     (descr "Net tie, 2 pin, 0.5mm square SMD pads")
     (tags "net tie")
@@
   )
   (footprint "NetTie:NetTie-2_SMD_Pad0.5mm" (layer "B.Cu")
-    (at 132.842 100.076)
+    (at 131.826 100.838)
     (descr "Net tie, 2 pin, 0.5mm square SMD pads")
     (tags "net tie")
@@
     (property "ki_keywords" "R res resistor")
     (attr smd)
-    (fp_text reference "R2" (at 0 1.43) (layer "B.SilkS")
+    (fp_text reference "R2" (at 0 -1.524) (layer "B.SilkS")
         (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
     )
@@
   (gr_rect (start 119 78) (end 160 116)
     (stroke (width 0.1) (type default)) (fill none) (layer "Edge.Cuts"))
+  (gr_text "Todo:\nConnector Silkscreen\nConnector Hole Clearance" (at 167.64 92.71) (layer "F.Cu")
+    (effects (font (size 1.5 1.5) (thickness 0.3) bold) (justify left bottom))
+  )
   (segment (start 155.194 105.918) (end 155.702 105.41) (width 0.25) (layer "B.Cu") (net 1))
   (segment (start 152.2245 105.918) (end 155.194 105.918) (width 0.25) (layer "B.Cu") (net 1))
   (segment (start 155.702 105.41) (end 155.702 98) (width 0.25) (layer "B.Cu") (net 1))
   (segment (start 158.242 98) (end 158.242 101.7035) (width 0.25) (layer "B.Cu") (net 2))
-  (segment (start 131.787 94.488) (end 128.275 98) (width 0.25) (layer "B.Cu") (net 3))
-  (segment (start 132.342 94.488) (end 131.787 94.488) (width 0.25) (layer "B.Cu") (net 3))
+  (segment (start 131.318 94.488) (end 128.275 97.531) (width 0.25) (layer "B.Cu") (net 3))
+  (segment (start 128.275 97.531) (end 128.275 98) (width 0.25) (layer "B.Cu") (net 3))
   (segment (start 125.45 98.285) (end 125.735 98) (width 0.25) (layer "B.Cu") (net 4))
   (segment (start 125.45 100.838) (end 125.45 98.285) (width 0.25) (layer "B.Cu") (net 4))
   (segment (start 125.704 97.567) (end 125.989 97.282) (width 0.25) (layer "B.Cu") (net 4))
+  (segment (start 133.236 100.698) (end 133.096 100.838) (width 0.5) (layer "B.Cu") (net 5))
+  (segment (start 133.236 100.076) (end 133.236 100.698) (width 0.5) (layer "B.Cu") (net 5))
   (segment (start 149.486 98.164) (end 149.606 98.044) (width 0.5) (layer "B.Cu") (net 5))
   (segment (start 152.288 84.074) (end 152.288 85.232) (width 0.5) (layer "B.Cu") (net 5))
   (segment (start 152.908 85.852) (end 152.908 96.52) (width 0.5) (layer "B.Cu") (net 5))
+  (segment (start 133.096 100.838) (end 132.326 100.838) (width 0.5) (layer "B.Cu") (net 5))
   (segment (start 149.486 100.076) (end 149.486 98.164) (width 0.5) (layer "B.Cu") (net 5))
   (segment (start 133.604 98.044) (end 149.606 98.044) (width 0.5) (layer "B.Cu") (net 5))
@@
   (segment (start 133.236 98.412) (end 133.604 98.044) (width 0.5) (layer "B.Cu") (net 5))
   (segment (start 152.908 96.52) (end 151.384 98.044) (width 0.5) (layer "B.Cu") (net 5))
+  (segment (start 133.35 95.162) (end 133.35 94.488) (width 0.5) (layer "B.Cu") (net 6))
   (segment (start 133.35 95.39) (end 133.236 95.276) (width 0.5) (layer "B.Cu") (net 6))
   (segment (start 151.288 93.568) (end 151.288 84.074) (width 0.5) (layer "B.Cu") (net 6))
   (segment (start 150.682 95.33) (end 150.682 96.714) (width 0.5) (layer "B.Cu") (net 6))
   (segment (start 150.736 94.12) (end 151.288 93.568) (width 0.5) (layer "B.Cu") (net 6))
+  (segment (start 133.35 94.488) (end 132.318 94.488) (width 0.5) (layer "B.Cu") (net 6))
   (segment (start 133.858 97.028) (end 150.368 97.028) (width 0.5) (layer "B.Cu") (net 6))
   (segment (start 150.736 95.276) (end 150.682 95.33) (width 0.5) (layer "B.Cu") (net 6))
   (segment (start 133.35 96.52) (end 133.858 97.028) (width 0.5) (layer "B.Cu") (net 6))
+  (segment (start 133.236 95.276) (end 133.35 95.162) (width 0.5) (layer "B.Cu") (net 6))
   (segment (start 150.682 96.714) (end 150.368 97.028) (width 0.5) (layer "B.Cu") (net 6))
   (segment (start 133.35 95.39) (end 133.35 96.52) (width 0.5) (layer "B.Cu") (net 6))
@@
   (segment (start 150.4525 104.968) (end 150.2645 105.156) (width 0.25) (layer "B.Cu") (net 33))
   (segment (start 154.0995 104.968) (end 150.4525 104.968) (width 0.25) (layer "B.Cu") (net 33))
-  (segment (start 131.58 100.838) (end 128.55 100.838) (width 0.25) (layer "B.Cu") (net 34))
-  (segment (start 132.342 100.076) (end 131.58 100.838) (width 0.25) (layer "B.Cu") (net 34))
+  (segment (start 128.55 100.838) (end 131.326 100.838) (width 0.25) (layer "B.Cu") (net 34))
   (zone (net 11) (net_name "GND") (layer "F.Cu") (hatch edge 0.5)
     (connect_pads (clearance 0.5))

Commit message: finish Xaar128-Adapter
Other:
- board text added: "VPPH"
- board text added: "Xaar 128 Printhead Adapter"
- board text added: "nRESET"
- board text removed: "Todo: Connector Silkscreen Connector Hole Clearance"
Changed lines of the file:
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@@
     (property "ki_keywords" "LED diode")
     (attr through_hole)
-    (fp_text reference "D2" (at 1.27 -2.96 180) (layer "F.SilkS")
+    (fp_text reference "D2" (at 1.27 3.004 180) (layer "F.SilkS")
         (effects (font (size 1 1) (thickness 0.15)))
     )
@@
     (property "ki_keywords" "mounting hole")
     (attr exclude_from_pos_files)
-    (fp_text reference "H1" (at 0 -3.35) (layer "F.SilkS")
+    (fp_text reference "H1" (at 0 -3.35) (layer "F.SilkS") hide
         (effects (font (size 1 1) (thickness 0.15)))
     )
@@
     (property "ki_keywords" "mounting hole")
     (attr exclude_from_pos_files)
-    (fp_text reference "H2" (at 0 -3.35) (layer "F.SilkS")
+    (fp_text reference "H2" (at 0 -3.35) (layer "F.SilkS") hide
         (effects (font (size 1 1) (thickness 0.15)))
     )
@@
     (property "ki_keywords" "connector")
     (attr smd)
-    (fp_text reference "J2" (at -8.75 -2.4 180 unlocked) (layer "B.SilkS") hide
-        (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
-    )
-    (fp_text value "Conn_02x15_Odd_Even" (at -8.75 -2.4 180 unlocked) (layer "B.Fab") hide
+    (fp_text reference "J2" (at -8.75 -2.4 180 unlocked) (layer "B.SilkS")
+        (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
+    )
+    (fp_text value "Conn_02x15_Odd_Even" (at -8.75 -2.4 180 unlocked) (layer "B.Fab")
         (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
     )
@@
         (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
     )
-    (fp_text user "30" (at -17.5 -7.5 180 unlocked) (layer "F.SilkS")
-        (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
-    )
-    (fp_text user "29" (at -17.5 2.5 180 unlocked) (layer "F.SilkS")
-        (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
-    )
-    (fp_text user "2" (at 0 -7.5 180 unlocked) (layer "F.SilkS")
+    (fp_text user "1" (at 0 2.5 180 unlocked) (layer "B.SilkS")
+        (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
+    )
+    (fp_text user "2" (at 0 -7.5 180 unlocked) (layer "B.Fab")
+        (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
+    )
+    (fp_text user "${REFERENCE}" (at -8.75 -2.4 180 unlocked) (layer "B.Fab")
         (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
     )
@@
         (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
     )
-    (fp_text user "2" (at 0 -7.5 180 unlocked) (layer "B.Fab")
+    (fp_text user "1" (at 0 2.5 180 unlocked) (layer "B.Fab")
         (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
     )
@@
     (fp_line (start 1.3465 -0.4188) (end -18.8465 -0.4188)
       (stroke (width 0.0254) (type solid)) (layer "B.Fab"))
-    (pad "" np_thru_hole circle (at -18.35 -4) (size 0.8 0.8) (drill 0.8) (layers "F&B.Cu" "*.Mask"))
-    (pad "" np_thru_hole circle (at 0.85 -4) (size 0.8 0.8) (drill 0.8) (layers "F&B.Cu" "*.Mask"))
+    (pad "" np_thru_hole circle (at -18.35 -4) (size 0.6 0.6) (drill 0.6) (layers "F&B.Cu" "*.Mask"))
+    (pad "" np_thru_hole circle (at 0.85 -4) (size 0.6 0.6) (drill 0.6) (layers "F&B.Cu" "*.Mask"))
     (pad "1" smd rect (at 0 0) (size 0.7112 2) (layers "B.Cu" "B.Paste" "B.Mask")
       (net 20 "nSS2") (pinfunction "Pin_1") (pintype "passive"))
-    (pad "2" smd rect (at 0 -4.8) (size 0.7112 2) (layers "B.Cu" "B.Paste" "B.Mask")
-      (net 6 "GNDH") (pinfunction "Pin_2") (pintype "passive"))
+    (pad "2" smd custom (at 0 -4.8) (size 0.1 0.1) (layers "B.Cu" "B.Paste" "B.Mask")
+      (net 6 "GNDH") (pinfunction "Pin_2") (pintype "passive")
+      (options (clearance outline) (anchor rect))
+      (primitives
+        (gr_poly
+          (pts
+            (xy 0.2 1)
+            (xy 0.3556 -1)
+            (xy -0.3556 -1)
+            (xy -0.3556 1)
+          )
+          (width 0) (fill yes))
+      ))
     (pad "3" smd rect (at -1.25 0) (size 0.7112 2) (layers "B.Cu" "B.Paste" "B.Mask")
       (net 5 "VPPH") (pinfunction "Pin_3") (pintype "passive"))
@@
     (pad "29" smd rect (at -17.5 0) (size 0.7112 2) (layers "B.Cu" "B.Paste" "B.Mask")
       (net 5 "VPPH") (pinfunction "Pin_29") (pintype "passive"))
-    (pad "30" smd rect (at -17.5 -4.8) (size 0.7112 2) (layers "B.Cu" "B.Paste" "B.Mask")
-      (net 6 "GNDH") (pinfunction "Pin_30") (pintype "passive"))
+    (pad "30" smd custom (at -17.5 -4.8) (size 0.1 0.1) (layers "B.Cu" "B.Paste" "B.Mask")
+      (net 6 "GNDH") (pinfunction "Pin_30") (pintype "passive")
+      (options (clearance outline) (anchor rect))
+      (primitives
+        (gr_poly
+          (pts
+            (xy -0.2 1)
+            (xy -0.3556 -1)
+            (xy 0.3556 -1)
+            (xy 0.3556 1)
+          )
+          (width 0) (fill yes))
+      ))
   )
   (footprint "NetTie:NetTie-2_SMD_Pad0.5mm" (layer "B.Cu")
@@
     (property "ki_keywords" "connector")
     (attr smd)
-    (fp_text reference "J3" (at 0 2.61) (layer "B.SilkS")
+    (fp_text reference "J3" (at -9.422 -1.39) (layer "B.SilkS")
         (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
     )
@@
     (property "ki_keywords" "connector")
     (attr smd)
-    (fp_text reference "J1" (at 0 2.61) (layer "B.SilkS") hide
-        (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
-    )
-    (fp_text value "Conn_01x21" (at 0 -5.39) (layer "B.Fab")
-        (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
-    )
-    (fp_text user "${REFERENCE}" (at 0 -1.39) (layer "B.Fab")
+    (fp_text reference "J1" (at -15.542 -1.376 180) (layer "B.SilkS")
+        (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
+    )
+    (fp_text value "Conn_01x21" (at 0 -5.39 180) (layer "B.Fab")
+        (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
+    )
+    (fp_text user "${REFERENCE}" (at 0 -1.39 180) (layer "B.Fab")
         (effects (font (size 1 1) (thickness 0.15)) (justify mirror))
     )
@@
   (gr_rect (start 119 78) (end 160 116)
     (stroke (width 0.1) (type default)) (fill none) (layer "Edge.Cuts"))
-  (gr_text "Todo:\nConnector Silkscreen\nConnector Hole Clearance" (at 167.64 92.71) (layer "F.Cu")
-    (effects (font (size 1.5 1.5) (thickness 0.3) bold) (justify left bottom))
+  (gr_text "Xaar 128 Printhead Adapter" (at 139.5 114) (layer "F.SilkS")
+    (effects (font (size 1 1) (thickness 0.15)) (justify bottom))
+  )
+  (gr_text "nRESET" (at 154.178 102) (layer "F.SilkS")
+    (effects (font (size 1 1) (thickness 0.15)) (justify left bottom))
+  )
+  (gr_text "VPPH" (at 124.968 102) (layer "F.SilkS")
+    (effects (font (size 1 1) (thickness 0.15)) (justify left bottom))
   )
   (segment (start 155.194 105.918) (end 155.702 105.41) (width 0.25) (layer "B.Cu") (net 1))

Commit message: drc & plots done
Changed lines of the file:
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@@
       (plot_on_all_layers_selection 0x0000000_00000000)
       (disableapertmacros false)
-      (usegerberextensions false)
+      (usegerberextensions true)
       (usegerberattributes true)
       (usegerberadvancedattributes true)
@@
       (plotinvisibletext false)
       (sketchpadsonfab false)
-      (subtractmaskfromsilk false)
+      (subtractmaskfromsilk true)
       (outputformat 1)
       (mirror false)
-      (drillshape 1)
+      (drillshape 0)
       (scaleselection 1)
-      (outputdirectory "")
+      (outputdirectory "plots/")
     )
   )
@@
     (fp_line (start 1.6 1.245) (end 1.6 -1.245)
       (stroke (width 0.1) (type solid)) (layer "B.Fab"))
-    (pad "1" smd roundrect (at -1.55 0) (size 1.3 2.65) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.192308)
+    (pad "1" smd roundrect (at -1.55 0) (size 1.3 2.65) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.1923076923)
       (net 4 "Net-(D2-A)") (pintype "passive"))
-    (pad "2" smd roundrect (at 1.55 0) (size 1.3 2.65) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.192308)
+    (pad "2" smd roundrect (at 1.55 0) (size 1.3 2.65) (layers "B.Cu" "B.Paste" "B.Mask") (roundrect_rratio 0.1923076923)
       (net 34 "Net-(NT1-Pad1)") (pintype "passive"))
     (model "${KICAD6_3DMODEL_DIR}/Resistor_SMD.3dshapes/R_1210_3225Metric.wrl"
