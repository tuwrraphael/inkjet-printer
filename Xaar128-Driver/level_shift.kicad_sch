File: Xaar128-Driver/level_shift.kicad_sch (KiCad schematic)
At the start: 28 parts, among them Q1 DMN2075U, U10 74AHCT125, U12 TXB0104D, U20 74AHCT125, U5 TXB0104D, U6 TXB0104D, U7 TXB0104D, U8 74AHCT125, U9 74AHCT125

Commit message: select remaining components, nucleo footprint
Parts:
- C1, C10, C2, C28, C29, C3, C30, C4, C5, C6, C8, C9: value 100n >16V Cer -> (none)
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "100n >16V Cer" (at 251.46 82.55 90)
+    (property "Value" "  " (at 251.46 82.55 90)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "100n >16V Cer" (at 53.34 25.4 90)
+    (property "Value" "  " (at 53.34 25.4 90)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "100n >16V Cer" (at 251.46 29.21 90)
+    (property "Value" "  " (at 251.46 29.21 90)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "100n >16V Cer" (at 114.3 81.28 90)
+    (property "Value" "  " (at 114.3 81.28 90)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "100n >16V Cer" (at 172.72 27.94 90)
+    (property "Value" "  " (at 172.72 27.94 90)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "100n >16V Cer" (at 238.76 29.21 90)
+    (property "Value" "  " (at 238.76 29.21 90)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "100n >16V Cer" (at 185.42 27.94 90)
+    (property "Value" "  " (at 185.42 27.94 90)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "100n >16V Cer" (at 40.64 25.4 90)
+    (property "Value" "  " (at 40.64 25.4 90)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "100n >16V Cer" (at 185.42 81.28 90)
+    (property "Value" "  " (at 185.42 81.28 90)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "100n >16V Cer" (at 118.11 26.67 90)
+    (property "Value" "  " (at 118.11 26.67 90)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "100n >16V Cer" (at 50.8 81.28 90)
+    (property "Value" "  " (at 50.8 81.28 90)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "100n >16V Cer" (at 105.41 26.67 90)
-      (effects (font (size 1.27 1.27)))
-    )
+    (property "Value" "  " (at 105.41 26.67 90)
+      (effects (font (size 1.27 1.27)))
+    )

Commit message: start xaar driver routing
Connections:
- net +3.3V: now also C4.2, U7.14 (VCCB); no longer C3.2, R24.1, U7.1 (VCCA)
- net +5V: now also C3.2, R24.1, U7.1 (VCCA); no longer C4.2, U7.14 (VCCB)
- net READY_IN: now also U10.12 (4A), U7.3 (A2); no longer U10.5 (2A), U7.12 (B2)
- net READY_OUT: now also U10.11 (4Y), U7.12 (B2); no longer U10.6 (2Y), U7.3 (A2)
- net nFAULT_IN: now also U7.2 (A1); no longer U7.13 (B1)
- net nFAULT_OUT: now also U7.13 (B1); no longer U7.2 (A1)
- net nRESET_FAULT_IN: now also U10.9 (3A), U7.5 (A4); no longer U10.12 (4A), U7.10 (B4)
- net nRESET_FAULT_OUT: now also U10.8 (3Y), U7.10 (B4); no longer U10.11 (4Y), U7.5 (A4)
- net nRESET_IN: now also U10.5 (2A), U7.4 (A3); no longer U10.9 (3A), U7.11 (B3)
- net nRESET_OUT: now also U10.6 (2Y), U7.11 (B3); no longer U10.8 (3Y), U7.4 (A3)

Commit message: xaar driver: some routed islands
Connections:
- net CLK_IN: now also U6.3 (A2), U9.12 (4A); no longer U6.2 (A1), U9.2 (1A)
- net CLK_OUT: now also U6.12 (B2), U9.11 (4Y); no longer U6.13 (B1), U9.3 (1Y)
- net MOSI_IN: now also U8.9 (3A); no longer U8.12 (4A)
- net MOSI_OUT: now also U8.8 (3Y); no longer U8.11 (4Y)
- net PHO_IN: now also U5.2 (A1), U8.2 (1A); no longer U6.4 (A3), U9.9 (3A)
- net PHO_OUT: now also U5.13 (B1), U8.3 (1Y); no longer U6.11 (B3), U9.8 (3Y)
- net READY_IN: now also U10.9 (3A), U7.5 (A4); no longer U10.12 (4A), U7.3 (A2)
- net READY_OUT: now also U10.8 (3Y), U7.10 (B4); no longer U10.11 (4Y), U7.12 (B2)
- net RESET_DISABLE_CP_IN: no longer U6.5 (A4)
- net RESET_DISABLE_CP_OUT: no longer U6.10 (B4)
- net SCK_IN: now also U8.5 (2A); no longer U8.9 (3A)
- net SCK_OUT: now also U8.6 (2Y); no longer U8.8 (3Y)
- net VPP_EN_CP_IN: now also U20.12 (4A); no longer U20.5 (2A)
- net VPP_EN_CP_OUT: now also U20.11 (4Y); no longer U20.6 (2Y)
- net nFAULT_IN: now also U10.12 (4A), U7.3 (A2); no longer U10.2 (1A), U7.2 (A1)
- net nFAULT_OUT: now also U10.11 (4Y), U7.12 (B2); no longer U10.3 (1Y), U7.13 (B1)
- net nFIRE_IN: now also U6.4 (A3); no longer U6.3 (A2)
- net nFIRE_OUT: now also U6.11 (B3); no longer U6.12 (B2)
- net nRESET_FAULT_IN: now also U10.2 (1A), U7.2 (A1); no longer U10.9 (3A), U7.5 (A4)
- net nRESET_FAULT_OUT: now also U10.3 (1Y), U7.13 (B1); no longer U10.8 (3Y), U7.10 (B4)
- net nSS1_IN: now also U5.3 (A2), U8.12 (4A); no longer U5.2 (A1), U8.2 (1A)
- net nSS1_OUT: now also U5.12 (B2), U8.11 (4Y); no longer U5.13 (B1), U8.3 (1Y)
- net nSS2_IN: now also U6.2 (A1), U9.2 (1A); no longer U5.3 (A2), U8.5 (2A)
- net nSS2_OUT: now also U6.13 (B1), U9.3 (1Y); no longer U5.12 (B2), U8.6 (2Y)
- no-connect marks 10 -> 12
