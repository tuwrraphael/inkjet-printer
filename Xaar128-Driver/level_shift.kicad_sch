File: Xaar128-Driver/level_shift.kicad_sch (KiCad schematic)
At the start: 21 parts, among them Q1 DMN2075U, U10 74AHCT125, U5 TXB0104D, U6 TXB0104D, U7 TXB0104D, U8 74AHCT125, U9 74AHCT125

Commit message: 5v monitoring
Parts:
- added C28, C29, C30: 100n, symbol Device:C
- added R19, R20: 100k, symbol Device:R
- added U12: TXB0104D, Package_SO:SOIC-14_3.9x8.7mm_P1.27mm, symbol Logic_LevelTranslator:TXB0104D
- added U20: 74AHCT125, symbol Xaar_Driver:74AHCT125
Connections:
- net +3.3V: now also C28.2, R19.1, U12.1 (VCCA)
- net +5V: now also C29.2, C30.2, U12.14 (VCCB), U20.14 (VCC)
- net GND: now also C28.1, C29.1, C30.1, R20.2, U12.7 (GND), U20.7 (GND)
- net RESET_DISABLE_CP_IN: now also U12.2 (A1), U20.2 (1A); no longer U9.12 (4A)
- net RESET_DISABLE_CP_OUT: now also U12.13 (B1), U20.3 (1Y); no longer U9.11 (4Y)
- new net: R20.1, U20.1 (~{1OE}), U20.10 (~{3OE}), U20.13 (~{4OE}), U20.4 (~{2OE})
- new net: R19.2, U12.8 (OE)
- new net VPP_EN_CP_IN: U12.3 (A2), U20.5 (2A)
- new net VPP_EN_CP_OUT: U12.12 (B2), U20.6 (2Y)
- no-connect marks 0 -> 10
Other:
- moved on the sheet: C1, C10, C2, C3, C4, C5, C6, C8, C9, R23, R24, U10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

Commit message: some component selections, fix wrong mcu
Parts:
- C1, C10, C2, C28, C29, C3, C30, C4, C5, C6, C8, C9: value 100n -> 100n >16V Cer; footprint (none) -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Supplier (none) -> Elektroplatz
- JP1: value CONN_RST -> Jumper_3_Bridged12; footprint (none) -> Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical; symbol Jumper:Jumper_3_Open -> Jumper:Jumper_3_Bridged12; Funktion (none) -> Connect Output Enable to nRESET
- Q1: RSBestNr (none) -> 751-4143; Supplier (none) -> RS
- U12, U5, U6, U7: RSBestNr (none) -> 709-2778; Supplier (none) -> RS

Commit message: assign footprints
Parts:
- JP1: Supplier (none) -> Elektroplatz
- R19, R20, R23, R24: footprint (none) -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; RSBestNr (none) -> 678-9673; Supplier (none) -> RS
- R25: footprint (none) -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; RSBestNr (none) -> 678-9875; Supplier (none) -> RS
- R26: footprint (none) -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Supplier (none) -> Elektroplatz
- U10, U20, U8, U9: footprint (none) -> Package_SO:SOIC-14_3.9x8.7mm_P1.27mm; RSBestNr (none) -> 798-8941; Supplier (none) -> RS
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (at 261.112 124.46 90)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder" (at 261.112 124.46 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "RSBestNr" "" (at 262.89 124.46 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Supplier" "" (at 262.89 124.46 0)
+    (property "RSBestNr" "678-9673" (at 262.89 124.46 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Supplier" "RS" (at 262.89 124.46 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (at 245.11 111.76 0)
+    (property "Footprint" "Package_SO:SOIC-14_3.9x8.7mm_P1.27mm" (at 245.11 111.76 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "RSBestNr" "" (at 245.11 111.76 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Supplier" "" (at 245.11 111.76 0)
+    (property "RSBestNr" "798-8941" (at 245.11 111.76 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Supplier" "RS" (at 245.11 111.76 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "" (at 228.6 43.688 90)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder" (at 228.6 43.688 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "RSBestNr" "" (at 228.6 41.91 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Supplier" "" (at 228.6 41.91 0)
+    (property "RSBestNr" "678-9673" (at 228.6 41.91 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Supplier" "RS" (at 228.6 41.91 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (at 179.07 110.49 0)
+    (property "Footprint" "Package_SO:SOIC-14_3.9x8.7mm_P1.27mm" (at 179.07 110.49 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "RSBestNr" "" (at 179.07 110.49 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Supplier" "" (at 179.07 110.49 0)
+    (property "RSBestNr" "798-8941" (at 179.07 110.49 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Supplier" "RS" (at 179.07 110.49 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (at 46.99 110.49 0)
+    (property "Footprint" "Package_SO:SOIC-14_3.9x8.7mm_P1.27mm" (at 46.99 110.49 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "RSBestNr" "" (at 46.99 110.49 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Supplier" "" (at 46.99 110.49 0)
+    (property "RSBestNr" "798-8941" (at 46.99 110.49 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Supplier" "RS" (at 46.99 110.49 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (at 118.872 156.21 90)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder" (at 118.872 156.21 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Supplier" "" (at 120.65 156.21 0)
+    (property "Supplier" "Elektroplatz" (at 120.65 156.21 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (at 110.49 110.49 0)
+    (property "Footprint" "Package_SO:SOIC-14_3.9x8.7mm_P1.27mm" (at 110.49 110.49 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "RSBestNr" "" (at 110.49 110.49 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Supplier" "" (at 110.49 110.49 0)
+    (property "RSBestNr" "798-8941" (at 110.49 110.49 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Supplier" "RS" (at 110.49 110.49 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (at 195.072 123.19 90)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder" (at 195.072 123.19 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "RSBestNr" "" (at 196.85 123.19 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Supplier" "" (at 196.85 123.19 0)
+    (property "RSBestNr" "678-9673" (at 196.85 123.19 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Supplier" "RS" (at 196.85 123.19 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Supplier" "" (at 97.79 154.94 0)
+    (property "Supplier" "Elektroplatz" (at 97.79 154.94 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "" (at 105.41 167.132 90)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder" (at 105.41 167.132 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "RSBestNr" "" (at 105.41 168.91 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Supplier" "" (at 105.41 168.91 0)
+    (property "RSBestNr" "678-9875" (at 105.41 168.91 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Supplier" "RS" (at 105.41 168.91 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "" (at 162.56 42.418 90)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder" (at 162.56 42.418 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "RSBestNr" "" (at 162.56 40.64 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Supplier" "" (at 162.56 40.64 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "RSBestNr" "678-9673" (at 162.56 40.64 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Supplier" "RS" (at 162.56 40.64 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
