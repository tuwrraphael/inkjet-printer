File: Xaar128-Driver/mcu.kicad_sch (KiCad schematic)
At the start: 7 parts

Commit message: 5v monitoring
Connections:
- net GND: now also U4.CN10_5 (GND)
- new net VPP_ENABLE_CP: U4.CN10_15 (PG2)
- no-connect marks 14 -> 20
Other:
- moved on the sheet: JP8, JP9

Commit message: some component selections, fix wrong mcu
Parts:
- removed JP8: SPI1_CLK, symbol Jumper:SolderJumper_2_Open
- added JP12, JP16: SolderJumper_2_Open, Resistor_SMD:R_0603_1608Metric, symbol Jumper:SolderJumper_2_Open
- added JP13, JP15, JP8: SolderJumper_2_Bridged, Resistor_SMD:R_0603_1608Metric, symbol Jumper:SolderJumper_2_Bridged
- JP10: value SPI3_MOSI -> SolderJumper_2_Open; footprint (none) -> Resistor_SMD:R_0603_1608Metric; symbol Jumper:SolderJumper_2_Bridged -> Jumper:SolderJumper_2_Open; Funktion (none) -> Connect MOSI to CN7; RSBestNr (none) -> 120-432; Supplier (none) -> RS
- JP11: value SPI3_CLK -> SolderJumper_2_Open; footprint (none) -> Resistor_SMD:R_0603_1608Metric; symbol Jumper:SolderJumper_2_Bridged -> Jumper:SolderJumper_2_Open; Funktion (none) -> Connect SCK to CN7; RSBestNr (none) -> 120-432; Supplier (none) -> RS
- JP3: value PHO_MCU -> SolderJumper_2_Bridged; footprint (none) -> Resistor_SMD:R_0603_1608Metric; Funktion (none) -> Disable MCU PHO Control; RSBestNr (none) -> 120-432; Supplier (none) -> RS
- JP9: value SPI1_CLK -> SolderJumper_2_Bridged; footprint (none) -> Resistor_SMD:R_0603_1608Metric; symbol Jumper:SolderJumper_2_Open -> Jumper:SolderJumper_2_Bridged; Funktion (none) -> Disconnes MOSI from Arduino; Supplier (none) -> None
- U4: value ~ -> NUCLEO-H743ZI2; symbol Xaar_Driver:NUCLEO-H745-Arduino -> Xaar_Driver:NUCLEO-H743-Arduino; RSBestNr (none) -> 193-9787; Supplier (none) -> RS
Connections:
- net CLK: now also JP12.2 (B), JP13.1 (A); no longer JP11.1 (A)
- net SCK: now also JP11.1 (A), JP8.2 (B); no longer U4.28 (PA5)
- net VPP_EN: now also JP15.2 (B), JP16.1 (A); no longer U4.17 (PG14)
- net VPP_ENABLE_CP: now also U4.13 (PC2); no longer U4.CN10_15 (PG2)
- net nFAULT: now also U4.CN7_7 (PB12); no longer U4.CN7_5 (PB13)
- net nRESET_FAULT: now also U4.14 (PF10); no longer U4.CN7_9 (PA15)
- net at U4.24 (PD15): now also JP13.2 (B)
- net at U4.21 (PE9): now also JP12.1 (A)
- new net: JP16.2 (B), U4.CN7_9 (PA15)
- new net: JP15.1 (A), U4.17 (PG14)
- new net: JP8.1 (A), U4.28 (PA5)
- no-connect marks 20 -> 18
Other:
- note added: "Ethernet"
- note removed: "Solder bridge required"
- note removed: "Solder bridge required?"
- note removed: "USB_SOF"
- note removed: "nc by default"

Commit message: assign footprints
Parts:
- R18: footprint (none) -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Supplier (none) -> Elektroplatz
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "" (at 124.46 121.412 90)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder" (at 124.46 121.412 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Supplier" "" (at 124.46 123.19 0)
+    (property "Supplier" "Elektroplatz" (at 124.46 123.19 0)
       (effects (font (size 1.27 1.27)) hide)
     )

Commit message: select remaining components, nucleo footprint
Parts:
- U4: footprint (none) -> Xaar-Driver:NUCLEO-H743
Connections:
- net GND: no longer U4.CN10_5 (GND)
- no-connect marks 18 -> 11
Changed lines of the file:
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@@
   (no_connect (at 191.77 81.28))
   (no_connect (at 116.84 64.77))
-  (no_connect (at 170.18 110.49))
   (no_connect (at 116.84 67.31))
   (no_connect (at 116.84 80.01))
@@
   (no_connect (at 191.77 66.04))
   (no_connect (at 137.16 110.49))
-  (no_connect (at 165.1 110.49))
   (no_connect (at 191.77 99.06))
-  (no_connect (at 167.64 110.49))
   (no_connect (at 191.77 96.52))
-  (no_connect (at 154.94 110.49))
-  (no_connect (at 162.56 110.49))
-  (no_connect (at 172.72 110.49))
   (no_connect (at 191.77 58.42))
-  (no_connect (at 157.48 110.49))
   (wire (pts (xy 201.93 63.5) (xy 212.09 63.5))
     (stroke (width 0) (type default))
@@
   )
   (wire (pts (xy 139.7 110.49) (xy 139.7 135.89))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 160.02 110.49) (xy 160.02 114.3))
     (stroke (width 0) (type default))
   )
@@
     )
   )
-  (symbol (lib_id "power:GND") (at 160.02 114.3 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR0113" (at 160.02 120.65 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GND" (at 160.02 119.38 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "" (at 160.02 114.3 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 160.02 114.3 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (instances
-      (project "Xaar128-Driver"
-        (path "/f0c82013-03f9-4093-aa02-30b89fd69529/1523239e-e45e-424d-91c2-0483c3ac8971"
-          (reference "#PWR0113") (unit 1)
-        )
-      )
-    )
-  )
   (symbol (lib_id "power:PWR_FLAG") (at 91.44 72.39 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "" (at 140.97 96.52 0)
+    (property "Footprint" "Xaar-Driver:NUCLEO-H743" (at 140.97 96.52 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "32")
     (pin "9")
-    (pin "CN10_1")
-    (pin "CN10_11")
-    (pin "CN10_13")
-    (pin "CN10_15")
-    (pin "CN10_3")
-    (pin "CN10_5")
-    (pin "CN10_7")
-    (pin "CN10_9")
     (pin "CN7_1")
     (pin "CN7_11")

Commit message: xaar driver: some routed islands
Parts:
- JP10, JP11, JP12, JP13, JP15, JP16, JP3, JP8, JP9: footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 142.24 116.84 0)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder" (at 142.24 116.84 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 147.32 116.84 0)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder" (at 147.32 116.84 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 198.12 93.98 0)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder" (at 198.12 93.98 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 132.08 116.84 0)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder" (at 132.08 116.84 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 198.12 68.58 0)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder" (at 198.12 68.58 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 149.86 116.84 0)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder" (at 149.86 116.84 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 198.12 83.82 0)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder" (at 198.12 83.82 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 198.12 63.5 0)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder" (at 198.12 63.5 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
-    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 198.12 73.66 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder" (at 198.12 73.66 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: more components routed
Connections:
- net COMM_ENABLE: now also U4.CN7_1 (PC6); no longer U4.CN7_3 (PB15)
- net READY: now also U4.14 (PF10); no longer U4.12 (PB1)
- net nRESET_FAULT: now also U4.9 (PA3); no longer U4.14 (PF10)
- net nRESET_IN: now also U4.12 (PB1); no longer U4.9 (PA3)
- net at JP3.2 (B): now also U4.CN7_3 (PB15); no longer U4.CN7_1 (PC6)
