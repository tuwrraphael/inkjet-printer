File: Xaar128-Driver/io.kicad_sch (KiCad schematic)
At the start: 5 parts, among them J1 Screw_Terminal_01x02, J3 Screw_Terminal_01x02, J4 Screw_Terminal_01x02, J7 Screw_Terminal_01x04

Commit message: some component selections, fix wrong mcu
Parts:
- NT5: footprint (none) -> NetTie:NetTie-2_SMD_Pad0.5mm; Supplier (none) -> None
Changed lines of the file:
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@@
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "RSBestNr" "" (at 144.78 88.9 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Supplier" "" (at 144.78 88.9 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "RSBestNr" "" (at 144.78 128.27 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Supplier" "" (at 144.78 128.27 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "Datasheet" "~" (at 144.78 99.06 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "RSBestNr" "" (at 144.78 99.06 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Supplier" "" (at 144.78 99.06 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (property "Datasheet" "~" (at 144.78 115.57 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "RSBestNr" "" (at 144.78 115.57 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Supplier" "" (at 144.78 115.57 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "" (at 120.65 121.92 0)
+    (property "Footprint" "NetTie:NetTie-2_SMD_Pad0.5mm" (at 120.65 121.92 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "RSBestNr" "" (at 120.65 121.92 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Supplier" "None" (at 120.65 121.92 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: assign footprints
Parts:
- J1, J3, J4: footprint (none) -> RS_PRO:Steckbarer_Klemmenblock_1x02_5.08mm_vertical; RSBestNr (none) -> 897-1238; Supplier (none) -> RS
- J7: footprint (none) -> RS_PRO:Steckbarer_Klemmenblock_1x04_5.08mm_vertical_copy; RSBestNr (none) -> 897-1240; Supplier (none) -> RS
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (at 144.78 88.9 0)
+    (property "Footprint" "RS_PRO:Steckbarer_Klemmenblock_1x04_5.08mm_vertical_copy" (at 144.78 88.9 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "RSBestNr" "" (at 144.78 88.9 0)
+    (property "RSBestNr" "897-1240" (at 144.78 88.9 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Supplier" "" (at 144.78 88.9 0)
+    (property "Supplier" "RS" (at 144.78 88.9 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (at 144.78 128.27 0)
+    (property "Footprint" "RS_PRO:Steckbarer_Klemmenblock_1x02_5.08mm_vertical" (at 144.78 128.27 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "RSBestNr" "" (at 144.78 128.27 0)
+    (property "RSBestNr" "897-1238" (at 144.78 128.27 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Supplier" "" (at 144.78 128.27 0)
+    (property "Supplier" "RS" (at 144.78 128.27 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (at 144.78 99.06 0)
+    (property "Footprint" "RS_PRO:Steckbarer_Klemmenblock_1x02_5.08mm_vertical" (at 144.78 99.06 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "RSBestNr" "" (at 144.78 99.06 0)
+    (property "RSBestNr" "897-1238" (at 144.78 99.06 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Supplier" "" (at 144.78 99.06 0)
+    (property "Supplier" "RS" (at 144.78 99.06 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (at 144.78 115.57 0)
+    (property "Footprint" "RS_PRO:Steckbarer_Klemmenblock_1x02_5.08mm_vertical" (at 144.78 115.57 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "RSBestNr" "" (at 144.78 115.57 0)
+    (property "RSBestNr" "897-1238" (at 144.78 115.57 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Supplier" "" (at 144.78 115.57 0)
+    (property "Supplier" "RS" (at 144.78 115.57 0)
       (effects (font (size 1.27 1.27)) hide)
     )

Commit message: xaar driver: some routed islands
Parts:
- removed NT5: NetTie_2, NetTie:NetTie-2_SMD_Pad0.5mm, symbol Device:NetTie_2
Connections:
- net GNDHP is gone; now on net GND1: J3.2 (Pin_2)
Changed lines of the file:
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@@
     (rev "1.0.0")
   )
-  (junction (at 110.49 121.92) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 123.19 118.11) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 110.49 118.11) (diameter 0) (color 0 0 0 0)
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 128.27 115.57) (xy 135.89 115.57))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 135.89 93.98) (xy 139.7 93.98))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 105.41 118.11) (xy 110.49 118.11))
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 128.27 115.57) (xy 135.89 115.57))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 110.49 121.92) (xy 118.11 121.92))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 135.89 93.98) (xy 139.7 93.98))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 105.41 121.92) (xy 110.49 121.92))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 135.89 101.6) (xy 139.7 101.6))
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 123.19 118.11) (xy 123.19 121.92))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 135.89 115.57) (xy 139.7 115.57))
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 110.49 118.11) (xy 123.19 118.11))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 125.73 113.03) (xy 128.27 113.03))
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 123.19 118.11) (xy 139.7 118.11))
+  (wire (pts (xy 110.49 118.11) (xy 139.7 118.11))
     (stroke (width 0) (type default))
   )
@@
     )
   )
-  (netclass_flag "" (length 2.54) (shape round) (at 116.84 121.92 180) (fields_autoplaced)
+  (netclass_flag "" (length 2.54) (shape round) (at 116.84 118.11 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right bottom))
-    (property "Netclass" "HV" (at 117.5385 124.46 0)
+    (property "Netclass" "HV" (at 117.5385 120.65 0)
       (effects (font (size 1.27 1.27) italic) (justify left))
     )
   )
-  (netclass_flag "" (length 2.54) (shape round) (at 127 118.11 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right bottom))
-    (property "Netclass" "HP" (at 127.6985 120.65 0)
-      (effects (font (size 1.27 1.27) italic) (justify left))
-    )
-  )
-  (symbol (lib_id "power:PWR_FLAG") (at 110.49 121.92 180) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#FLG06" (at 110.49 123.825 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "PWR_FLAG" (at 110.49 126.8632 0)
+  (symbol (lib_id "power:PWR_FLAG") (at 110.49 118.11 180) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#FLG06" (at 110.49 120.015 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "PWR_FLAG" (at 110.49 123.0532 0)
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "" (at 110.49 121.92 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 110.49 121.92 0)
+    (property "Footprint" "" (at 110.49 118.11 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 110.49 118.11 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_id "power:PWR_FLAG") (at 110.49 118.11 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#FLG05" (at 110.49 116.205 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "PWR_FLAG" (at 110.49 113.03 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "" (at 110.49 118.11 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 110.49 118.11 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (instances
-      (project "Xaar128-Driver"
-        (path "/f0c82013-03f9-4093-aa02-30b89fd69529/8d2d865b-5c5b-48bf-9eef-a5e158c4d497"
-          (reference "#FLG05") (unit 1)
-        )
-      )
-    )
-  )
   (symbol (lib_id "power:+5V") (at 135.89 128.27 90) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
-  (symbol (lib_id "power:GND1") (at 105.41 121.92 270) (unit 1)
+  (symbol (lib_id "power:GND1") (at 105.41 118.11 270) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "#PWR096" (at 99.06 121.92 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GND1" (at 101.6 121.92 90)
+    (property "Reference" "#PWR096" (at 99.06 118.11 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND1" (at 101.6 118.11 90)
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Footprint" "" (at 105.41 121.92 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 105.41 121.92 0)
+    (property "Footprint" "" (at 105.41 118.11 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 105.41 118.11 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
         )
       )
-    )
-  )
-  (symbol (lib_id "Xaar_Driver:GNDHP") (at 105.41 118.11 270) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "#PWR067" (at 99.06 118.11 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GNDHP" (at 101.6 118.11 90)
-      (effects (font (size 1.27 1.27)) (justify right))
-    )
-    (property "Footprint" "" (at 105.41 118.11 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 105.41 118.11 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (instances
-      (project "Xaar128-Driver"
-        (path "/f0c82013-03f9-4093-aa02-30b89fd69529/8d2d865b-5c5b-48bf-9eef-a5e158c4d497"
-          (reference "#PWR067") (unit 1)
-        )
-      )
-    )
-  )
-  (symbol (lib_id "Device:NetTie_2") (at 120.65 121.92 0) (unit 1)
-    (in_bom no) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "NT5" (at 120.65 116.84 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "NetTie_2" (at 120.65 119.38 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Footprint" "NetTie:NetTie-2_SMD_Pad0.5mm" (at 120.65 121.92 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 120.65 121.92 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "RSBestNr" "" (at 120.65 121.92 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Supplier" "None" (at 120.65 121.92 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (pin "2")
-    (instances
-      (project "Xaar128-Driver"
-        (path "/f0c82013-03f9-4093-aa02-30b89fd69529/8d2d865b-5c5b-48bf-9eef-a5e158c4d497"
-          (reference "NT5") (unit 1)
-        )
-      )

Commit message: more routing
Connections:
- net LEDPWRGND is gone; now on net GND: J7.4 (Pin_4)
Changed lines of the file:
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@@
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 135.89 99.06) (xy 139.7 99.06))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 135.89 101.6) (xy 139.7 101.6))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 105.41 118.11) (xy 110.49 118.11))
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 135.89 101.6) (xy 139.7 101.6))
+  (wire (pts (xy 134.62 91.44) (xy 139.7 91.44))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 134.62 88.9) (xy 139.7 88.9))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 125.73 113.03) (xy 128.27 113.03))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (global_label "LEDPWRGND" (shape input) (at 135.89 93.98 180) (fields_autoplaced)
+  (wire (pts (xy 134.62 86.36) (xy 139.7 86.36))
+    (stroke (width 0) (type default))
+  )
+  (hierarchical_label "LED+" (shape input) (at 134.62 88.9 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 121.5958 93.98 0)
-      (effects (font (size 1.27 1.27)) (justify right) hide)
-    )
-  )
-  (hierarchical_label "LED+" (shape input) (at 139.7 88.9 180) (fields_autoplaced)
+  )
+  (hierarchical_label "LED-" (shape input) (at 134.62 91.44 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
   )
-  (hierarchical_label "LED-" (shape input) (at 139.7 91.44 180) (fields_autoplaced)
+  (hierarchical_label "LED_PWR" (shape output) (at 134.62 86.36 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
   )
-  (hierarchical_label "LED_PWR" (shape output) (at 139.7 86.36 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right))
-  )
-  (hierarchical_label "nFIRE" (shape input) (at 139.7 99.06 180) (fields_autoplaced)
+  (hierarchical_label "nFIRE" (shape input) (at 135.89 99.06 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
   )
@@
         )
       )
+    )
+  )
+  (symbol (lib_id "power:GND") (at 135.89 93.98 270) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR067" (at 129.54 93.98 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 132.08 93.98 90)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Footprint" "" (at 135.89 93.98 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 135.89 93.98 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "Xaar128-Driver"
+        (path "/f0c82013-03f9-4093-aa02-30b89fd69529/8d2d865b-5c5b-48bf-9eef-a5e158c4d497"
+          (reference "#PWR067") (unit 1)
+        )
+      )
