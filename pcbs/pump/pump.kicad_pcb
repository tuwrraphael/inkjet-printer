# Repository tuwrraphael/inkjet-printer (continued)

## KiCad design pcbs/Xaar128-Driver/Xaar128-Driver.kicad_pcb (continued)

Parts:
C7: 100n >16V Cer; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: BZX84C10LT1G 10V; SOT-23
D3: LED green Vf=1.8V; LED_D5.0mm
D4: LED red Vf=1.6V; LED_D5.0mm
D6: BZX84C27LT1G 27V; SOT-23
JP4, JP5, JP6, JP7: Jumper_3_Bridged12; PinHeader_1x03_P2.54mm_Vertical
NT4: NetTie_2; NetTie-2_SMD_Pad0.5mm
Q1, Q2: DMN5L06K-7; SOT-23
Q3, Q10: DMN2075U; SOT-23
Q11: DMG2305UX; SOT-23; not fitted
R1: 1.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 31.6k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 5.1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4: 68k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6: 1.6k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8, R12, R22: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: 5.1k >300mW; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10: 2k > 700mW; R_2010_5025Metric_Pad1.40x2.65mm_HandSolder
R11, R46: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14, R15, R16, R17, R45: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R49: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
TP1, TP2, TP3, TP4: TestPoint; TestPoint_Pad_D1.5mm
U1, U2: 6N135; DIP-8_W7.62mm
U3: 74HC173; SO-16_3.9x9.9mm_P1.27mm

Connections:
+5V: C7.1, Q11.2 (S), R13.1, R45.2, U1.8, U2.8, U3.16 (VCC); also elsewhere on the board
+36V: NT4.1; also elsewhere on the board
/HV Supply/VPPL: R3.1, R10.1; also elsewhere on the board
/Level Shift/RESET_DISABLE_CP_OUT: U3.7 (Cp); also elsewhere on the board
/Level Shift/nFAULT_IN: R22.1, R46.1; also elsewhere on the board
/Level Shift/nRESET_FAULT_IN: JP7.2 (C), Q11.1 (G), R13.2, TP3.1, U3.15 (Mr); also elsewhere on the board
/Level Shift/nRESET_IN: TP4.1, U3.3 (Q0); also elsewhere on the board
/MCU/nRESET_MCU: R11.1, R12.1; also elsewhere on the board
unnamed: D1.1 (A), R6.1, R8.1
unnamed: D1.3 (K), R3.2, R4.1
unnamed: D3.2 (A), U1.3
unnamed: D3.1 (K), Q1.3 (D)
unnamed: D4.2 (A), U2.3
unnamed: D4.1 (K), Q2.3 (D)
unnamed: D6.1 (A), R5.1, R7.1
unnamed: JP4.1 (A), U1.6
unnamed: JP4.3 (B), JP6.2 (C), U1.5
unnamed: JP4.2 (C), JP5.3 (B), U2.5
unnamed: JP5.1 (A), U2.6
unnamed: JP5.2 (C), JP7.3 (B), Q10.2 (S)
unnamed: JP6.1 (A), Q3.3 (D)
unnamed: JP7.1 (A), Q10.3 (D)
unnamed: NT4.2, R1.1, R9.1
unnamed: Q1.1 (G), R7.2, TP1.1
unnamed: Q2.1 (G), R8.2, TP2.1
unnamed: Q3.1 (G), R12.2
unnamed: Q10.1 (G), R22.2
unnamed: Q11.3 (D), R45.1, R49.2, U3.14 (D0)
unnamed: R9.2, U1.2
unnamed: R10.2, U2.2
unnamed: R15.1, U3.9 (~E1)
unnamed: R14.1, U3.10 (~E2)
unnamed: R17.1, U3.1 (~OE1)
unnamed: R16.1, U3.2 (~OE2)

Notes on the sheet:
Vf = 1.4V
5V/20kOhm = 0.25mA CTR of 5% 0.25mA/0.05 = 5mA i_f
Test if Optocoupler turns on with only 6mA
Matlab Optimization at +36V = 36V => ≈4.3V at ≈30.9 => ≈1.6V at 30V => ≈1.1V at ≈28.6V => 0.3V
Matlab Optimization at VPP = 35V => ≈6V at ≈17V => ≈1.7V at 15V => ≈1V at ≈12V => 0.3V

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_2.7mm_M2.5_DIN965
J1, J2, J3, J4, J7: Screw_Terminal_01x02; 897-1051

Connections:
+5V: J4.1; also elsewhere on the board
+36V: J3.1; also elsewhere on the board
/IO/LED+: J7.2; also elsewhere on the board
/IO/LED-: J2.1; also elsewhere on the board
/IO/LED_PWR: J7.1; also elsewhere on the board
/IO/nFIRE: J1.1; also elsewhere on the board

Schematic: strobe.kicad_sch, Xaar 128 Driver

Parts:
C1: 100n >16V Film; C_Rect_L7.0mm_W3.5mm_P5.00mm
NT7: NetTie_2; NetTie-2_SMD_Pad0.5mm
Q9: DMN2075U; SOT-23
R2: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
/IO/LED+: NT7.2; also elsewhere on the board
/IO/LED-: Q9.3 (D); also elsewhere on the board
/IO/LED_PWR: NT7.1; also elsewhere on the board

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
Board: 2 copper layers, 100.0 x 100.0 mm, 188 parts (132 on the bottom side), 131 nets.

Other parts of the board:
C27: 100n >16V Film; C_Rect_L7.0mm_W3.5mm_P5.00mm
R43: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Their connections:
/MCU/STROBE: C27.1; also elsewhere on the board

## KiCad design Heatbed/Heatbed.kicad_pcb

Board: 2 copper layers, 30.5 x 33.0 mm, 14 parts (0 on the bottom side), 9 nets.

Parts:
D1: D; D_A-405_P7.62mm_Horizontal
D2: LED; LED_D3.0mm
J1: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J2: Conn_01x03; TerminalBlock_bornier-3_P5.08mm
J4: Conn_01x02; TerminalBlock_bornier-2_P5.08mm
Q1: IPP060N06N; TO-220-3_Vertical
Q2: BS170; TO-92_Inline_Wide
R1: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R2: 7.5k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R3, R6: 22k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R4, R5: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R7: 4k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal

Connections:
+24: J2.2, J2.3, R1.1, R3.1, R7.1
GND: J2.1, J4.2, Q1.3 (S), Q2.3 (S), R2.2, R6.2
HB-: D2.1 (K), J4.1, Q1.2 (D)
HB_ACTIVE: D1.1 (K), J1.1
unnamed: D1.2 (A), R1.2, R2.1, R4.1
unnamed: D2.2 (A), R7.2
unnamed: Q1.1 (G), R5.2
unnamed: Q2.1 (D), R3.2, R5.1, R6.1
unnamed: Q2.2 (G), R4.2

## KiCad design Xaar128-Adapter/Xaar128-Adapter.kicad_pcb

Parts:
D1: LED yellow Vf=1.6V; LED_D3.0mm
D2: LED green Vf=1.8V; LED_D3.0mm
H1, H2: MountingHole; MountingHole_2.7mm_M2.5_DIN965
J1: Conn_01x21; Molex_200528-0210_1x21-1MP_P1.00mm_Horizontal
J2: Conn_02x15_Odd_Even; CONN_9-176140-0_TYC
J3: Conn_01x12; Molex_52207-1260_1x12-1MP_P1.00mm_Horizontal; not fitted
NT1, NT2: NetTie_2; NetTie-2_SMD_Pad0.5mm
Q1: DMN2075U; SOT-23
R1: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R3: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 5.1k >300mW; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
+5V: J1.12, J2.17, R1.1, R4.2
/MISO: J2.27
CLK: J1.3, J2.28
GND: J1.2, J1.4, J1.8, J1.10, J1.13, J1.15, J2.16, J3.12, Q1.2 (S), R2.1
GNDH: J1.20, J2.2, J2.30, NT2.1
GNDL: J1.18, J2.5
MOSI: J1.14, J2.8
unnamed: D1.2 (A), R4.1
unnamed: D1.1 (K), Q1.3 (D)
unnamed: D2.2 (A), R6.1
unnamed: D2.1 (K), NT2.2
unnamed: NT1.1, R6.2
unnamed: Q1.1 (G), R3.1
PHO: J1.6, J2.25
READY: J1.7, J2.24
SCK: J1.11, J2.19
TEST_0: J2.9, J3.1
TEST_1: J2.10, J3.2
TEST_2: J2.11, J3.3
TEST_3: J2.12, J3.4
TEST_4: J2.13, J3.5
TEST_5: J2.14, J3.6
TEST_6: J2.15, J3.7
TEST_7: J2.21, J3.9
TEST_8: J2.22, J3.10
TEST_9: J2.23, J3.11
TEST_10: J2.18, J3.8, R1.2
VPPH: J1.21, J2.3, J2.29, NT1.2
VPPL: J1.19, J2.4
nFAULT: J1.17, J2.6
nFIRE: J1.5, J2.26
nRESET: J1.16, J2.7, R2.2, R3.2
nSS1: J1.9, J2.20
nSS2: J1.1, J2.1

Notes on the sheet:
min pin height: 3mm insert depth: 2mm

Board: 2 copper layers, 41.0 x 38.0 mm, 15 parts (11 on the bottom side), 33 nets.

## KiCad design Strobe/Strobe.kicad_pcb

Parts:
C1: 100n; C_Disc_D7.5mm_W5.0mm_P5.00mm
C2: 220u; CP_Radial_D5.0mm_P2.50mm
J1: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J2: Screw_Terminal_01x03; TerminalBlock_bornier-3_P5.08mm
Q1, Q2: IPP060N06N; TO-220-3_Vertical
Q3, Q4: BS170; TO-92_Inline_Wide
R1: 1R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R3, R5: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 100R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1, RV2: 10K; Potentiometer_ACP_CA9-H5_Horizontal

Connections:
CTRL: C1.1, J1.1, R5.2
GND: C2.2, J2.3, Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), R4.1, R5.1
LED+: C2.1, J1.2, J2.1, R3.2, RV2.1
LED-: J2.2, Q1.2 (D)
unnamed: Q1.1 (G), Q2.1 (G), Q3.1 (D), R2.2
unnamed: Q2.2 (D), R1.2, R2.1
unnamed: Q3.2 (G), Q4.1 (D), R3.1
unnamed: C1.2, Q4.2 (G), RV1.2
unnamed: R1.1, RV2.2
unnamed: R4.2, RV1.3

Board: 2 copper layers, 33.0 x 76.2 mm, 15 parts (0 on the bottom side), 10 nets.

## KiCad design FPC_Adapter/FPC_Adapter.kicad_pcb

Parts:
J1: Conn_01x21_Pin; PinHeader_1x21_P2.54mm_Vertical
J2: Conn_01x09_Pin; PinHeader_1x09_P2.54mm_Vertical
J3, J4, J5, J6: Conn_01x21_Pin; Molex_200528-0210_1x21-1MP_P1.00mm_Horizontal
J7, J8, J9, J10: Conn_01x09_Pin; Molex_200528-0090_1x09-1MP_P1.00mm_Horizontal

Connections:
unnamed: J1.1, J3.1, J4.21, J5.21, J6.1
unnamed: J1.2, J3.2, J4.20, J5.20, J6.2
unnamed: J1.3, J3.3, J4.19, J5.19, J6.3
unnamed: J1.4, J3.4, J4.18, J5.18, J6.4
unnamed: J1.5, J3.5, J4.17, J5.17, J6.5
unnamed: J1.6, J3.6, J4.16, J5.16, J6.6
unnamed: J1.7, J3.7, J4.15, J5.15, J6.7
unnamed: J1.8, J3.8, J4.14, J5.14, J6.8
unnamed: J1.9, J3.9, J4.13, J5.13, J6.9
unnamed: J1.10, J3.10, J4.12, J5.12, J6.10
unnamed: J1.11, J3.11, J4.11, J5.11, J6.11
unnamed: J1.12, J3.12, J4.10, J5.10, J6.12
unnamed: J1.13, J3.13, J4.9, J5.9, J6.13
unnamed: J1.14, J3.14, J4.8, J5.8, J6.14
unnamed: J1.15, J3.15, J4.7, J5.7, J6.15
unnamed: J1.16, J3.16, J4.6, J5.6, J6.16
unnamed: J1.17, J3.17, J4.5, J5.5, J6.17
unnamed: J1.18, J3.18, J4.4, J5.4, J6.18
unnamed: J1.19, J3.19, J4.3, J5.3, J6.19
unnamed: J1.20, J3.20, J4.2, J5.2, J6.20
unnamed: J1.21, J3.21, J4.1, J5.1, J6.21
unnamed: J2.1, J7.1, J8.9, J9.9, J10.1
unnamed: J2.2, J7.2, J8.8, J9.8, J10.2
unnamed: J2.3, J7.3, J8.7, J9.7, J10.3
unnamed: J2.4, J7.4, J8.6, J9.6, J10.4
unnamed: J2.5, J7.5, J8.5, J9.5, J10.5
unnamed: J2.6, J7.6, J8.4, J9.4, J10.6
unnamed: J2.7, J7.7, J8.3, J9.3, J10.7
unnamed: J2.8, J7.8, J8.2, J9.2, J10.8
unnamed: J2.9, J7.9, J8.1, J9.1, J10.9

Board: 2 copper layers, 36.0 x 84.0 mm, 10 parts (4 on the bottom side), 30 nets.

## Code that names these connections

File Xaar128-Driver-Firmware/Xaar128-Driver-Firmware.ioc (part):

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Mcu.Name=STM32H7A3Z(G-I)TxQ
Mcu.Package=LQFP144
Mcu.UserName=STM32H7A3ZITxQ
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=USB_FS_ID [ZX62RD-AB-5P8_ID]
PA10.Mode=OTG/Dual-Role-Device-FS
PA10.Signal=USB_OTG_HS_ID
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=USB_FS_N [USBLC6-2SC6_IO_1]
PA11.Mode=OTG/Dual-Role-Device-FS
PA11.Signal=USB_OTG_HS_DM
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=USB_FS_P [USBLC6-2SC6_IO_2]
PA12.Mode=OTG/Dual-Role-Device-FS
PA12.Signal=USB_OTG_HS_DP
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=nRESET_FAULT
PA3.Signal=GPIO_Input
PA5.Mode=TX_Only_Simplex_Unidirect_Master
PA5.Signal=SPI1_SCK
PA7.Mode=TX_Only_Simplex_Unidirect_Master
PA7.Signal=SPI1_MOSI
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=USB_FS_VBUS  [ZX62RD-AB-5P8_VBUS]
PA9.Mode=Activate_VBUS_FS
PA9.Signal=USB_OTG_HS_VBUS
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=LD1 (Green Led)
PB0.Signal=GPIO_Output
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=nRESET_IN
PB1.Signal=GPIO_Input
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=nFAULT
PB12.Signal=GPIO_Input
PB14.GPIOParameters=GPIO_Label
PB14.GPIO_Label=LD3 (Red Led)
PB14.Signal=GPIO_Output
PB15.GPIOParameters=GPIO_Label
PB15.GPIO_Label=PHO
PB15.Signal=GPIO_Output
PB8.Mode=I2C
PB8.Signal=I2C1_SCL
PB9.Mode=I2C
PB9.Signal=I2C1_SDA
PC0.GPIOParameters=GPIO_Label
PC0.GPIO_Label=RESET_DISABLE_CP
PC0.Signal=GPIO_Output
PC1.GPIOParameters=GPIO_Label
PC1.GPIO_Label=VPP_ENABLE_CP
PC1.Signal=GPIO_Output
PC13.GPIOParameters=GPIO_Label
PC13.GPIO_Label=B1 (Blue PushButton)
PC13.Signal=GPIO_Input
PC14-OSC32_IN.GPIOParameters=GPIO_Label
PC14-OSC32_IN.GPIO_Label=OSC32_IN
PC14-OSC32_IN.Mode=LSE-External-Oscillator
PC14-OSC32_IN.Signal=RCC_OSC32_IN
PC15-OSC32_OUT.GPIOParameters=GPIO_Label
PC15-OSC32_OUT.GPIO_Label=OSC32_OUT
PC15-OSC32_OUT.Mode=LSE-External-Oscillator
PC15-OSC32_OUT.Signal=RCC_OSC32_OUT
PC2_C.GPIOParameters=GPIO_Label
PC2_C.GPIO_Label=nRESET_MCU
PC2_C.Signal=GPIO_Output
PC6.GPIOParameters=GPIO_Label
PC6.GPIO_Label=COMM_ENABLE
PC6.Signal=GPIO_Output
PD15.GPIOParameters=GPIO_Label
PD15.GPIO_Label=XAAR_CLK
PD15.Signal=S_TIM4_CH4
PD8.GPIOParameters=GPIO_Label
PD8.GPIO_Label=STLINK_RX
PD8.Mode=Asynchronous
PD8.Signal=USART3_TX
PD9.GPIOParameters=GPIO_Label
PD9.GPIO_Label=STLINK_TX
PD9.Mode=Asynchronous
PD9.Signal=USART3_RX
PE1.GPIOParameters=GPIO_Label
PE1.GPIO_Label=LD2 (Yellow Led)
PE1.Signal=GPIO_Output
PE11.GPIOParameters=GPIO_Label
PE11.GPIO_Label=nFIRE
PE11.Signal=S_TIM1_CH2
PE13.GPIOParameters=GPIO_Label
PE13.GPIO_Label=STROBE
PE13.Signal=S_TIM1_CH3
PF10.GPIOParameters=GPIO_Label
PF10.GPIO_Label=USB_FS_PWR_EN [STMPS2141STR_EN]
PF10.Signal=GPIO_Output
PF11.GPIOParameters=GPIO_Label
PF11.GPIO_Label=READY
PF11.Signal=GPIO_Input
PG14.GPIOParameters=GPIO_Label
PG14.GPIO_Label=VPP_EN
PG14.Signal=GPIO_Output
PG7.GPIOParameters=GPIO_Label
PG7.GPIO_Label=USB_FS_OVCR  [STMPS2141STR_FAULT]
PG7.Signal=GPXTI7
PG9.GPIOParameters=GPIO_Label
PG9.GPIO_Label=nSS2
PG9.Signal=GPIO_Output
PH0-OSC_IN.GPIOParameters=GPIO_Label
PH0-OSC_IN.GPIO_Label=PH0-MCU
PH0-OSC_IN.Mode=HSE-External-Clock-Source
PH0-OSC_IN.Signal=RCC_OSC_IN
PH1-OSC_OUT.GPIOParameters=GPIO_Label
PH1-OSC_OUT.GPIO_Label=PH1-MCU
PH1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=96000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=NUCLEO-H7A3ZI-Q
boardIOC=true

## Commit log

2023-11-03 initial
2023-11-15 dropwatcher signals look good on scope
2023-11-17 circuit working with led
2023-12-11 fpc adapter & strobe
2023-12-11 Xaar Driver & Adapter
2023-12-11 adapter mostly done
2023-12-12 finish Xaar128-Adapter
2023-12-12 5v monitoring
2023-12-12 some component selections, fix wrong mcu
2023-12-13 assign footprints
2023-12-15 select remaining components, nucleo footprint
2023-12-18 start xaar driver routing
2023-12-18 xaar driver: some routed islands
2023-12-18 xaar driver pcb: order elements
2023-12-22 more components routed
2023-12-28 more routing
2024-01-03 almost
2024-01-04 routing done
2024-01-05 drc & plots done
2024-01-08 add acc and text
2024-01-08 fix caps
2024-01-08 create order list
2024-01-08 Create plots for fabrication
2024-01-11 received parts
2024-01-12 bootstrap Xaar-128-Driver-Firmware
2024-01-15 received last item
2024-01-17 add nucleo-h7a3
2024-01-17 switch mcu
2024-01-17 strobe/nfire timer combined pwm mode
2024-01-22 example-application buildable
2024-01-23 bootstrap printer device
2024-01-24 combined pwm fire working
2024-01-31 pinout tested
2024-01-31 spi works
2024-02-01 printhead activate routine
2024-02-16 pressure sensor
2024-02-23 driver for motor and pressure sensor
2024-02-23 pump and pressure sensor perfboard
2024-02-23 implement pressure control on nucleo
2024-02-23 west update
2024-02-26 started shutdown routines
2024-02-27 continue routines
2024-02-27 continue failure handling
2024-02-28 dropwatcher system state
2024-02-28 fire cmd + spi fixed
2024-03-01 first test tinkering
2024-03-08 use nanopb
2024-03-08 start webusb
2024-03-08 implement some webusb requests
2024-03-08 downgrade zephyr to fix webusb
2024-03-11 fix light and fire timing
2024-03-13 fix pressure control timout, refactor it, webusb system state
2024-03-14 update grapp template
2024-03-18 dropwatcher hmr
2024-03-22 pressure control using webapp
2024-03-22 move stage
2024-03-26 print task runner
2024-03-27 handle printhead ready, nozzle data via usb
2024-03-27 start dropwatcher ui
2024-03-28 refactor msg names
2024-03-28 dropwatcher camera view
2024-04-13 inventor cad models
2024-04-13 t-piece
2024-04-18 cad sync
2024-04-19 lab book and random files
2024-04-19 fix nozzle bit/shift order
2024-04-19 higher camera holder
2024-04-26 dropwatcher wip stuff
2024-04-29 encoder mount1
2024-05-06 capping assembly 2 start
2024-05-06 rotating capping first print
2024-05-06 encoder mount
2024-05-08 rotating capping
2024-05-13 encoder
2024-05-16 capping two magnets
2024-05-17 asa cover
2024-05-19 fix references
2024-05-21 capping rubber printed
2024-05-21 capping straight
2024-05-24 ordering voltage regulator extension
2024-05-28 prepare encoder library for testing
2024-05-29 encoder print unit tests
2024-05-29 encoder diagrams
2024-05-29 cad stuff
2024-05-29 encoder control
2024-05-29 fix direct timer references
2024-05-31 fire timing wip
2024-06-03 interrupt priorities
2024-06-03 fire timing, direct isr
2024-06-04 prepare print_control for test
2024-06-04 max speed calculations
2024-06-05 first encoder prints working, detect data slow
2024-06-10 print memory, flip encoder direction
2024-06-17 web slicer wip
2024-06-18 live slicer & write data
2024-06-18 remove printsim
2024-06-19 slicer works
2024-06-21 zoom and rendering fixes
2024-06-22 slicer improvements for first print
2024-06-24 test code
2024-06-24 save/load files
2024-06-24 favicons
2024-06-24 model params
2024-06-26 remove cubemx project
2024-06-27 changable voltage, encoder pause mode
2024-07-02 slicer moved to worker, fix start print in the middle bug
2024-07-02 rasterizing at an angle
2024-07-03 sort-out-overprinting
2024-07-04 initial ink control value
2024-07-04 priming close the max frequency
2024-07-05 nozzle correction kind of working
2024-07-07 perfboard supports two pumps
2024-07-07 add cable slot to pump mount
2024-07-08 microscope mount
2024-07-08 test second pump
2024-07-08 perfboard with second pump
2024-07-10 dual pump control from webusb
2024-07-15 fix keepalive
2024-07-15 fix dac address r
2024-07-15 regulator factor
2024-07-17 finish second pump control & monitoring
2024-07-17 start regulator control
2024-07-17 regulator control (not tested with opv yet)
2024-07-17 heatbed pcb
2024-07-19 final heatbed circuit
2024-07-22 switch opv to lm358
2024-07-22 more wip
2024-07-24 model groups done
2024-07-25 fix import path
2024-07-26 various ink supply functions
2024-07-26 camera calibration & layers calculation
2024-07-28 fix inkcontrol actions
2024-07-28 fix model scolling issue
2024-07-28 fix slice next btn
2024-08-06 automatic photos
2024-08-09 fix dot diameter
2024-08-09 better voltage test
2024-08-09 priming while drying
2024-08-09 autofocus cache
2024-08-09 microscope position calibration
2024-08-09 fix model group properties overridden by photopoint placement
2024-08-09 increase microscope autofocus speed
2024-08-09 prevent move down when homing
2024-08-09 refine ink control actions
2024-08-09 increase max voltage
2024-08-13 inspect printed drop analysis
2024-08-16 randomize tracks
2024-08-16 clock control & dropwatcher sweeps
2024-08-19 drying fan speed
2024-08-19 start scanline track rasterizer
2024-08-20 randomized/align offset
2024-08-22 prime while drying
2024-08-22 do not reset rng for each layer
2024-08-23 realthing2
2024-08-25 correct pmos
2024-08-26 ux refactoring
2024-08-27 fix scanline rasterizer
2024-08-27 nozzletest view
2024-08-29 fix randomize bug, semi automatic nozzle test working
2024-08-29 ink m
2024-08-30 improve pause/resume
2024-08-30 finetuning while printing with new nozzle test
2024-09-02 refactor clock/voltage test generation
2024-09-02 camera: timeout; task runner: resume failed
2024-09-02 start camera view
2024-09-05 visual homing
2024-09-05 testprint ink o
2024-10-11 dropwatcher with priming
2024-10-23 irix adaption, sample holder, dropwatcher adjustments
2024-10-25 makeimage
2024-11-18 fix nmos
2025-02-15 drop measurements in inspect
2025-02-15 display dryer temperature
2025-02-26 implement heater
2025-02-26 fix visual homing
2025-03-02 remove legacy cad files
2025-03-02 remove dropwatcher-hw pcb
2025-03-02 rename inkjet-printer-web
2025-03-02 remove legacy strobe pcb
2025-03-02 remove unrelated docs and tools
2025-03-02 remove fpc-adapter
2025-03-02 move pcbs to pcbs folder
2025-03-02 readme & licensing
2025-03-02 remove img
2025-03-03 fix typo
2025-03-03 fix readme
