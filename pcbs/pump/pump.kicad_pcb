# Repository tuwrraphael/inkjet-printer

File README.md:

# Inkjet Printer

This repository contains the code, PCB, and CAD of the custom-designed inkjet printer for printing ceramic thin films, which was created as part of the master thesis [Development of an Inkjet Printer for Electrolyte Layers of Oxygen Ion Batteries](https://doi.org/10.34726/hss.2024.116604).
<br clear="right"/>

---

See a preview of the control software: [https://tuwrraphael.github.io/inkjet-printer/](https://tuwrraphael.github.io/inkjet-printer/).

<p align="center">
 
 <br>
 An overview image of the implemented inkjet printer.
</p>

Details about the printer, challenges and design decisions, its application and evaluation can be found in the [thesis](https://repositum.tuwien.at/bitstream/20.500.12708/208972/1/Hauk%20Raphael%20-%202024%20-%20Development%20of%20an%20Inkjet%20Printer%20for%20Electrolyte%20Layers%20of...pdf).

Repository structure:
* [inkjet-printer-app](inkjet-printer-app): A web app that controls the printer, is used for planning print jobs, print monitoring & evaluation, calibration and maintenance. Runs in a browser using WebUSB and WebSerial for communicating with the hardware. A deployed version to test an be found [here](https://tuwrraphael.github.io/inkjet-printer/).
* [inkjet-printer-zephyr](inkjet-printer-zephyr): The Zephyr based firmware of the printhead drive electronics.
* [pcbs/Xaar128-Driver](pcbs/Xaar128-Driver): The main PBC design of the printhead drive electronics.
* [cad](cad): Various CAD files of attachments added to the printer.

## Cite this work
The main purpose of publishing this repository is to provide insights into the development of a custom inkjet printer. If you got inspired or found parts of this project useful, please cite the thesis.
~~~
@mastersthesis{HaukRaphael2024DoaI,
  title = {Development of an Inkjet Printer for Electrolyte Layers of Oxygen Ion Batteries},
  author = {Hauk, Raphael},
  year    = 2024,
  school  = {TU Wien},
  address = {Vienna, Austria},
  type    = {{Master's thesis}},
  note     = {Available at: \url{https://doi.org/10.34726/hss.2024.116604}}
}
~~~

## Acknowledgements
This research was funded in part by the Austrian Science Fund (FWF) [10.55776/COE5](https://doi.org/10.55776/COE5).

## Licensing
The firmware builds on Zephyr Project, which is licensed under the Apache License 2.0.
Tools and libraries used in the control software are listed in the app [here](https://tuwrraphael.github.io/inkjet-printer/info).

## KiCad design pcbs/pump/pump.kicad_pcb

Parts:
J1, J2: Conn_01x08_Socket; PinSocket_1x08_P2.54mm_Vertical
J3, J8: Conn_01x04_Socket; PinSocket_1x04_P2.54mm_Vertical
J4, J5, J7: Screw_Terminal_01x02; Steckbarer_Klemmenblock_1x02_5.08mm_horizontal
J6, J9: Conn_01x01_Socket; PinSocket_1x01_P2.54mm_Vertical
R1: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal

Connections:
+3.3V: J1.2, J6.1, J9.1, R1.2
+5V: J1.1, J5.2
A01: J1.4, J7.2
A02: J1.5, J7.1
AIN1: J2.3, J8.4
AIN2: J2.2, J8.3
B01: J1.7, J4.1
B02: J1.6, J4.2
BIN1: J2.5, J3.2
BIN2: J2.6, J3.3
GND: J1.3, J1.8, J2.8, J3.1, J5.1, J8.2
unnamed: J2.4, R1.1
PWMA: J2.1, J8.1
PWMB: J2.7, J3.4

Board: 2 copper layers, 10 parts (0 on the bottom side), 14 nets.

## KiCad design pcbs/Xaar128-Driver/Xaar128-Driver.kicad_pcb

Parts:
J5: Conn_01x21; Molex_200528-0210_1x21-1MP_P1.00mm_Horizontal
J6: Conn_02x08_Odd_Even; IDC-Header_2x08_P2.54mm_Vertical; not fitted

Connections:
+5V: J5.10; also elsewhere on the board
/HV Supply/VPPH: J5.1, J6.3; also elsewhere on the board
/HV Supply/VPPL: J5.3, J6.4; also elsewhere on the board
/IO/nFIRE: J5.17, J6.14; also elsewhere on the board
/Level Shift/CLK_OUT: J5.19, J6.15; also elsewhere on the board
/Level Shift/MOSI_OUT: J5.8, J6.9; also elsewhere on the board
/Level Shift/PHO_OUT: J5.16, J6.13; also elsewhere on the board
/Level Shift/READY_IN: J5.15, J6.12; also elsewhere on the board
/Level Shift/SCK_OUT: J5.11, J6.10; also elsewhere on the board
/Level Shift/nFAULT_IN: J5.5, J6.7; also elsewhere on the board
/Level Shift/nRESET_IN: J5.6, J6.8; also elsewhere on the board
/Level Shift/nSS1_OUT: J5.13, J6.11; also elsewhere on the board
/Level Shift/nSS2_OUT: J5.21, J6.1; also elsewhere on the board

Parts:
JP3, JP8, JP9, JP13, JP15: SolderJumper_2_Bridged; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
JP10, JP11, JP12, JP16: SolderJumper_2_Open; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R18: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
U4: NUCLEO-H743ZI2; NUCLEO-H743

Connections:
+5V: U4.5 (5V); also elsewhere on the board
/ACC/SCL: U4.32 (PB8); also elsewhere on the board
/ACC/SDA: U4.31 (PB9); also elsewhere on the board
/HV Supply/VPP_EN: JP15.2 (B), JP16.1 (A); also elsewhere on the board
/Level Shift/CLK_IN: JP12.2 (B), JP13.1 (A); also elsewhere on the board
/Level Shift/COMM_ENABLE: U4.CN7_1 (PC6); also elsewhere on the board
/Level Shift/MOSI_IN: JP9.2 (B), JP10.1 (A); also elsewhere on the board
/Level Shift/PHO_IN: JP3.1 (A), R18.2; also elsewhere on the board
/Level Shift/READY_OUT: U4.14 (PF11); also elsewhere on the board
/Level Shift/RESET_DISABLE_CP_IN: U4.10 (PC0); also elsewhere on the board
/Level Shift/SCK_IN: JP8.2 (B), JP11.1 (A); also elsewhere on the board
/Level Shift/VPP_EN_CP_IN: U4.11 (PC3); also elsewhere on the board
/Level Shift/nFAULT_OUT: U4.CN7_7 (PB12); also elsewhere on the board
/Level Shift/nFIRE_IN: U4.20 (PE11); also elsewhere on the board
/Level Shift/nRESET_FAULT_OUT: U4.9 (PA3); also elsewhere on the board
/Level Shift/nRESET_OUT: U4.12 (PB1); also elsewhere on the board
/Level Shift/nSS1_IN: U4.19 (PE14); also elsewhere on the board
/Level Shift/nSS2_IN: U4.23 (PG9); also elsewhere on the board
/MCU/STROBE: U4.18 (PE13); also elsewhere on the board
/MCU/nRESET_MCU: U4.13 (PC2); also elsewhere on the board
unnamed: JP3.2 (B), U4.CN7_3 (PB15)
unnamed: JP8.1 (A), U4.28 (PA5)
unnamed: JP9.1 (A), U4.26 (PA7)
unnamed: JP10.2 (B), U4.CN7_13 (PB5)
unnamed: JP11.2 (B), U4.CN7_15 (PB3)
unnamed: JP12.1 (A), U4.21 (PA8)
unnamed: JP13.2 (B), U4.24 (PD15)
unnamed: JP15.1 (A), U4.17 (PG14)
unnamed: JP16.2 (B), U4.CN7_9 (PA15)

Notes on the sheet:
SMPS_PG
SPI
Ethernet
USART

Parts:
C11, C16: 1u >72V Cer; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; not fitted
C12: 10u >72V E; CP_Radial_D5.0mm_P2.00mm
C13: 220u >72V E; CP_Radial_D13.0mm_P5.00mm
C14: 220u >72V E; CP_Radial_D13.0mm_P5.00mm; not fitted
C15: 1u >72V Cer; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C31: 100n >16V Cer; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D5: 3.3V; D_SOD-123F
D7: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
D8: 1N4007; D_DO-41_SOD81_P12.70mm_Horizontal
D9: 5.1V; D_DO-35_SOD27_P7.62mm_Horizontal
F1: 630mA/F; FUSE_646_1_LTF
JP14: Jumper_3_Bridged12; PinHeader_1x03_P2.54mm_Vertical
Q4, Q5: DMN2075U; SOT-23
Q7, Q8: SI2319CDS-T1-GE3; SOT-23
R21, R44, R50, R51, R52, R54: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R27: 12k > 200mW; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R28: 5.1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R29, R55, R58: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R56: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R57: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R59: 680; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP5, TP10, TP13: TestPoint; TestPoint_Pad_D1.5mm
U19: LTV-356T; SO-4_4.4x3.6mm_P2.54mm
U21: 74HC173; SO-16_3.9x9.9mm_P1.27mm

Connections:
+5V: C31.1, D5.1 (K), R50.2, R54.1, U21.16 (VCC); also elsewhere on the board
/HV Supply/VPP: F1.1; also elsewhere on the board
/HV Supply/VPPH: Q7.3 (D); also elsewhere on the board
/HV Supply/VPPL: Q8.3 (D); also elsewhere on the board
/HV Supply/VPP_EN: R55.1, R56.1, R59.1; also elsewhere on the board
/HV Supply/VPP_ENABLE_CP_5: U21.7 (Cp); also elsewhere on the board
/HV Supply/VPP_Feedback: C11.1, C12.1, C15.1, D8.1 (K), D9.1 (K), Q8.2 (S), R28.1; also elsewhere on the board
unnamed: D5.2 (A), R57.1, R58.1
unnamed: D7.2 (A), D8.2 (A), F1.2
unnamed: C13.1, C14.1, C16.1, D7.1 (K), Q7.2 (S)
unnamed: D9.2 (A), Q7.1 (G), Q8.1 (G), R27.1, R28.2, TP5.1
unnamed: JP14.1 (A), R29.2
unnamed: JP14.3 (B), R59.2
unnamed: JP14.2 (C), U19.1
unnamed: Q4.3 (D), R54.2, U21.15 (Mr)
unnamed: Q4.1 (G), R55.2
unnamed: Q4.2 (S), Q5.3 (D)
unnamed: Q5.1 (G), R58.2
unnamed: R27.2, TP10.1, U19.4
unnamed: R50.1, U21.14 (D0)
unnamed: R29.1, TP13.1, U21.3 (Q0)
unnamed: R44.1, U21.9 (~E1)
unnamed: R21.1, U21.10 (~E2)
unnamed: R52.1, U21.1 (~OE1)
unnamed: R51.1, U21.2 (~OE2)

Notes on the sheet:
Fuse Location: + must be before split because only one is monitored - energy stored in caps can cause problems when fuse is open?

Parts:
C17, C19: 2.2u >72V E; CP_Radial_D5.0mm_P2.00mm
C18: 10u >72V E; CP_Radial_D5.0mm_P2.00mm
C20, C25: 10u > 16V Tantal; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder; not fitted
C21, C22, C23, C24, C26: 100n >16V Cer; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; not fitted
D10: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
HS1: Heatsink; SK68-375-SA
JP2: Jumper_3_Bridged12; PinHeader_1x03_P2.54mm_Vertical
NT1, NT3: NetTie_2; NetTie-2_SMD_Pad0.5mm
R30: 200; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R31: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R32: 2.2k > 600mW; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R33, R34, R35, R36, R60: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R37, R41: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R38: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R39, R42: 12k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; not fitted
R40: 3k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal; not fitted
RV1: 10k RC103B; Potentiometer_Alps_RK09L_Single_Vertical
TP6, TP7, TP8, TP9, TP11, TP12: TestPoint; TestPoint_Pad_D1.5mm
U11: LM317_TO-220; TO-220-3_Vertical
U13: MCP4725xxx-xCH; SOT-23-6_Handsoldering; not fitted
U14: ISO1541; SOIC-8_3.9x4.9mm_P1.27mm; not fitted
U15: L7824; TO-220-3_Vertical; not fitted
U16: MC78L05_SOT89; SOT-89-3; not fitted
U17: LM358; DIP-8_W7.62mm; not fitted
U18: MCP3021; SOT-23-5_HandSoldering; not fitted

Connections:
+5VP: C20.1, C21.1, C23.2, C25.1, C26.1, R33.1, R34.1, U13.3 (VDD), U14.8 (VCC2), U16.1 (OUT), U18.1 (VDD)
+24V: C24.2, U15.3 (OUT), U16.3 (IN), U17.8 (V+)
+36V: C17.1, NT3.2, U11.3 (VI); also elsewhere on the board
/ACC/SCL: R35.2, U14.3 (SCL1); also elsewhere on the board
/ACC/SDA: R36.2, U14.2 (SDA1); also elsewhere on the board
/HV Supply/VPP: C19.1, NT1.1, U11.2 (VO); also elsewhere on the board
/HV Supply/VPP_Feedback: R41.1; also elsewhere on the board
unnamed: C18.1, D10.2 (A), JP2.2 (C), R30.2, TP8.1, U11.1 (ADJ)
unnamed: D10.1 (K), NT1.2, R30.1
unnamed: JP2.1 (A), R32.1
unnamed: JP2.3 (B), R37.1, R38.2
unnamed: R31.1, R32.2, RV1.1
unnamed: R38.1, R39.2, TP7.1, U17.1
unnamed: R60.1, U13.6 (A0)
unnamed: TP6.1, U13.1 (VOUT), U17.3 (+)
unnamed: NT3.1, U15.1 (IN)
unnamed: R39.1, R40.2, U17.2 (-)
unnamed: R41.2, R42.1, TP9.1, U18.3 (AIN)
SCL_HV: R34.2, TP12.1, U13.5 (SCL), U14.6 (SCL2), U18.5 (SCL)
SDA_HV: R33.2, TP11.1, U13.4 (SDA), U14.7 (SDA2), U18.4 (SDA)

Notes on the sheet:
Remember constant load of LM317
V_pp = 1.25 * ( 1 + (R32 + (R31 * RV1/(R31 + RV1)))/R30) Output from 15-34.75 with nonlinearity - for better linearity, switch 10k and 4k7 (4k7k poti expensive..) minimum load current is 6.5mA, plus the leds and optocouplers at reset circuit should be enough

Parts:
C33: 100n >16V Cer; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; not fitted
JP17, JP18, JP19, JP20: SolderJumper_2_Open; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
NT2, NT5: NetTie_2; NetTie-2_SMD_Pad0.5mm
R47, R48, R53: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
TP14, TP15: TestPoint; TestPoint_Pad_D1.5mm
U22: LIS2DH; LGA-14_2x2mm_P0.35mm_LayoutBorder3x4y; not fitted

Connections:
/ACC/SCL: JP20.2 (B); also elsewhere on the board
/ACC/SDA: JP19.2 (B); also elsewhere on the board
unnamed: C33.1, JP17.1 (A), NT5.2, R47.2, R53.2
unnamed: C33.2, JP18.2 (B), NT2.2, R48.1
unnamed: JP19.1 (A), U22.2 (SDA/SDI)
unnamed: JP20.1 (A), U22.1 (SCL/SPC)
unnamed: NT2.1, U22.9 (GND), U22.10 (GND), U22.11 (GND), U22.12 (GND), U22.13 (GND), U22.14 (GND)
unnamed: TP14.1, U22.6 (INT1)
unnamed: TP15.1, U22.5 (INT2)
unnamed: R48.2, R53.1, U22.3 (SDO)
unnamed: NT5.1, U22.7 (Vdd_IO), U22.8 (Vdd)
unnamed: R47.1, U22.4 (~CS)

Parts:
C1, C2, C3, C4, C5, C6, C28, C30: 100n >16V Cer; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; not fitted
C8, C9, C10, C29: 100n >16V Cer; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
JP1: Jumper_3_Bridged12; PinHeader_1x03_P2.54mm_Vertical
Q6: DMN2075U; SOT-23
R19, R24: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R20, R23: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R25: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R26: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U5, U6, U7, U12: TXB0104D; SOIC-14_3.9x8.7mm_P1.27mm; not fitted
U8, U9, U10, U20: 74AHCT125; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+5V: C2.2, C3.2, C6.2, C8.2, C9.2, C29.2, C30.2, R24.1, R26.1, U5.14 (VCCB), U6.14 (VCCB), U7.1 (VCCA), U8.14 (VCC), U9.14 (VCC), U12.14 (VCCB), U20.14 (VCC); also elsewhere on the board
/HV Supply/VPP_ENABLE_CP_5: U12.12 (B2), U20.11 (4Y); also elsewhere on the board
/IO/nFIRE: U6.11 (B3), U9.6 (2Y); also elsewhere on the board
/Level Shift/CLK_IN: U6.3 (A2), U9.12 (4A); also elsewhere on the board
/Level Shift/CLK_OUT: U6.12 (B2), U9.11 (4Y); also elsewhere on the board
/Level Shift/COMM_ENABLE: JP1.1 (A); also elsewhere on the board
/Level Shift/MOSI_IN: U5.5 (A4), U8.9 (3A); also elsewhere on the board
/Level Shift/MOSI_OUT: U5.10 (B4), U8.8 (3Y); also elsewhere on the board
/Level Shift/PHO_IN: U5.2 (A1), U8.2 (1A); also elsewhere on the board
/Level Shift/PHO_OUT: U5.13 (B1), U8.3 (1Y); also elsewhere on the board
/Level Shift/READY_IN: U7.5 (A4), U10.9 (3A); also elsewhere on the board
/Level Shift/READY_OUT: U7.10 (B4), U10.8 (3Y); also elsewhere on the board
/Level Shift/RESET_DISABLE_CP_IN: U12.2 (A1), U20.2 (1A); also elsewhere on the board
/Level Shift/RESET_DISABLE_CP_OUT: U12.13 (B1), U20.3 (1Y); also elsewhere on the board
/Level Shift/SCK_IN: U5.4 (A3), U8.5 (2A); also elsewhere on the board
/Level Shift/SCK_OUT: U5.11 (B3), U8.6 (2Y); also elsewhere on the board
/Level Shift/VPP_EN_CP_IN: U12.3 (A2), U20.12 (4A); also elsewhere on the board
/Level Shift/nFAULT_IN: U7.3 (A2), U10.12 (4A); also elsewhere on the board
/Level Shift/nFAULT_OUT: U7.12 (B2), U10.11 (4Y); also elsewhere on the board
/Level Shift/nFIRE_IN: U6.4 (A3), U9.5 (2A); also elsewhere on the board
/Level Shift/nRESET_FAULT_IN: U7.2 (A1), U10.2 (1A); also elsewhere on the board
/Level Shift/nRESET_FAULT_OUT: U7.13 (B1), U10.3 (1Y); also elsewhere on the board
/Level Shift/nRESET_IN: JP1.3 (B), U7.4 (A3), U10.5 (2A); also elsewhere on the board
/Level Shift/nRESET_OUT: U7.11 (B3), U10.6 (2Y); also elsewhere on the board
/Level Shift/nSS1_IN: U5.3 (A2), U8.12 (4A); also elsewhere on the board
/Level Shift/nSS1_OUT: U5.12 (B2), U8.11 (4Y); also elsewhere on the board
/Level Shift/nSS2_IN: U6.2 (A1), U9.2 (1A); also elsewhere on the board
/Level Shift/nSS2_OUT: U6.13 (B1), U9.3 (1Y); also elsewhere on the board
unnamed: Q6.1 (G), R25.1
unnamed: R24.2, U7.8 (OE)
unnamed: R23.1, U10.1 (~1OE), U10.4 (~2OE), U10.10 (~3OE), U10.13 (~4OE)
unnamed: R19.2, U12.8 (OE)
unnamed: R20.1, U20.1 (~1OE), U20.4 (~2OE), U20.10 (~3OE), U20.13 (~4OE)
OE_OUT: JP1.2 (C), R25.2, U5.8 (OE), U6.8 (OE)
~OE_OUT: Q6.3 (D), R26.2, U8.1 (~1OE), U8.4 (~2OE), U8.10 (~3OE), U8.13 (~4OE), U9.1 (~1OE), U9.4 (~2OE), U9.10 (~3OE), U9.13 (~4OE)

Notes on the sheet:
MCU->5V Logic
MCU -> Printhead
Printhead/Reset Circuit -> MCU
